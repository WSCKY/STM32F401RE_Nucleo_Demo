# Keil uVision project bmp_encode.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bmp_encode
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,
  c misc: --c99
  c include: ..\inc;..\main;..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\Ext_Board\inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares\Third_Party\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group startup
    ./: startup_stm32f401xe.s
  group main
    ../main/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group board
    ../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
    ../../Drivers/Ext_Board/src/: stm32f4xx_nucleo_ExtSD.c stm32f4xx_nucleo_ExtLCD.c stm32f4xx_nucleo_Ext25Q16.c stm32f4xx_nucleo_ExtLCDBK.c
    ../src/: stm32f4xx_nucleo_ExtBMP_Enc.c
  group periph
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group FATFS/Core
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group FATFS/Driver
    ../../Drivers/Ext_Board/src/: sd_diskio.c
