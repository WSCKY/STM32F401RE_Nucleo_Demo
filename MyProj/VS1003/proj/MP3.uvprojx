# Keil uVision project MP3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: MP3
  AfterMake: "D:\KEIL MDK\Setup\ARM\ARMCC\bin\fromelf.exe" --bin -o ..\proj\image.bin ..\proj\opt\MP3.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,
  c misc: --C99
  c include: ..\inc;..\main;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Middlewares\Third_Party\FatFs\src;..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group periph
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_ll_sdmmc.c
  group board
    ../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
    ../src/: VS1003.c SDCard.c
  group startup
    ./: startup_stm32f401xe.s
  group main
    ../main/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group FatFs/Drivers
    ../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
