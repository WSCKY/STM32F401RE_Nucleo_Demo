# Keil uVision project ds18b20.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ds18b20
  AfterMake: "D:\KEIL MDK\Setup\ARM\ARMCC\bin\fromelf.exe"  --bin -o ..\proj\image.bin ..\proj\opt\ds18b20.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,
  c misc: --c99
  c include: ..\inc;..\main;..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\Ext_Board\inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group startup
    ./: startup_stm32f401xe.s
  group main
    ../main/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group board
    ../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
    ../../Drivers/Ext_Board/src/: stm32f4xx_nucleo_ExtLCD.c stm32f4xx_nucleo_Ext25Q16.c stm32f4xx_nucleo_ExtLCDBK.c stm32f4xx_nucleo_ExtTIMDelay.c
    ../src/: stm32f4xx_nucleo_ExtDS18B20.c
  group periph
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
